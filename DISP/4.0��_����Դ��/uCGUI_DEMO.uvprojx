# Keil uVision project uCGUI_DEMO.uvprojx, settings and files
target uCGUI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tiky_uCGUI_DEMO +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\user;.\CMSIS;.\FWlib\inc;.\TFT_ILI9328
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_Basic
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
    ./FWlib/src/: misc.c
  group user
    ./user/: main.c
  group FWlib
    ./FWlib/src/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c
  group LCD
    ./TFT_ILI9328/: ILI9325.c
software components: CMSIS:CORE 4.3.0
